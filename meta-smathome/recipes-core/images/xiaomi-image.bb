SUMMARY = "Image for Xiaomi Smart Home "
LICENSE = "CLOSED"

inherit core-image

IMAGE_INSTALL += "packagegroup-core-boot"
